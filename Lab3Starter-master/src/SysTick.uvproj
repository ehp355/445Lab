# Keil uVision project SysTick.uvproj, settings and files
target SysTick (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SysTick
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c main.c fixed.c ST7735.c fixed.h ST7735.h AlarmClockVisual.h AlarmClockVisual.c AlarmClockAudio.c AlarmClockAudio.h AlarmClockSwitchControl.c AlarmClockSwitchControl.h SysTick.c SysTick.h SysTickTestMain.c ClockImages.c ClockImages.h FallingEdgeInterrupt.c FallingEdgeInterrupt.h Timer0A.c Timer0A.h
